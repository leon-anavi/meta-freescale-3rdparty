FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://sound.cfg"
